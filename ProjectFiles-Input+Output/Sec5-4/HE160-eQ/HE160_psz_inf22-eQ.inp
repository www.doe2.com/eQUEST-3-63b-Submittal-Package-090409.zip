INPUT ..


$ ---------------------------------------------------------
$              Abort, Diagnostics
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Global Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Title, Run Periods, Design Days, Holidays
$ ---------------------------------------------------------

TITLE           
   LINE-1           = *Kamel Haddad, mod' by M Addison*
   LINE-2           = *IEA HVAC BESTEST: Furnace Test Cases*
   LINE-3           = *CASE HE160*
   ..

RUN-PERIOD-PD
   BEGIN-MONTH      = 1
   BEGIN-DAY        = 1
   BEGIN-YEAR       = 1959
   END-MONTH        = 3
   END-DAY          = 31
   END-YEAR         = 1959
   ..


"Standard US Holidays" = HOLIDAYS        
   TYPE             = NONE
   ..


$ ---------------------------------------------------------
$              Compliance Data
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Site and Building Data
$ ---------------------------------------------------------

"SITE-PARAMETERS 1" = SITE-PARAMETERS 
   LATITUDE         = 45.32
   LONGITUDE        = 75.67
   TIME-ZONE        = 5
   ALTITUDE         = 0
   DAYLIGHT-SAVINGS = NO
   ..

"BUILD-PARAMETERS 1" = BUILD-PARAMETERS
   AZIMUTH          = 0
   ..



$ ---------------------------------------------------------
$              Materials / Layers / Constructions
$ ---------------------------------------------------------

"WALLMAT" = MATERIAL        
   TYPE             = RESISTANCE
   RESISTANCE       = 568.18
   ..
"FLOORMAT" = MATERIAL        
   TYPE             = RESISTANCE
   RESISTANCE       = 568.18
   ..
"ROOFMAT" = MATERIAL        
   TYPE             = RESISTANCE
   RESISTANCE       = 568.18
   ..


"HOUSEWALL" = CONSTRUCTION    
   TYPE             = U-VALUE
   ABSORPTANCE      = 0.01
   ROUGHNESS        = 1
   U-VALUE          = 0.0017611
   ..
"HOUSEFLOOR" = CONSTRUCTION    
   TYPE             = U-VALUE
   ABSORPTANCE      = 0.01
   ROUGHNESS        = 1
   U-VALUE          = 0.0017611
   ..
"HOUSEROOF" = CONSTRUCTION    
   TYPE             = U-VALUE
   ABSORPTANCE      = 0.01
   ROUGHNESS        = 1
   U-VALUE          = 0.0017611
   ..


$ ---------------------------------------------------------
$              Glass Type Codes
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Glass Types
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Window Layers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Lamps / Luminaries / Lighting Systems
$ ---------------------------------------------------------





$ ---------------------------------------------------------
$              Day Schedules
$ ---------------------------------------------------------

"Day Schedule   1" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   2" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 
         99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99 )
   ..
"Day Schedule   3" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 
         68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68 )
   ..
"Day Schedule   4" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   5" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..

$ ---------------------------------------------------------
$              Week Schedules
$ ---------------------------------------------------------

"Week Schedule  1" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "Day Schedule   1", "Day Schedule   1", 
         "Day Schedule   1", "Day Schedule   1", "Day Schedule   1", 
         "Day Schedule   1", "Day Schedule   1", "Day Schedule   1" )
   ..
"Week Schedule  2" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   2", "Day Schedule   2", 
         "Day Schedule   2", "Day Schedule   2", "Day Schedule   2", 
         "Day Schedule   2", "Day Schedule   2", "Day Schedule   2" )
   ..
"Week Schedule  3" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3" )
   ..
"Week Schedule  4" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4" )
   ..
"Week Schedule  5" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5" )
   ..

$ ---------------------------------------------------------
$              Annual Schedules
$ ---------------------------------------------------------

"LIGHT-SCH" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  1" )
   ..
"COOLING-SCH" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  2" )
   ..
"HEATING-SCH" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  3" )
   ..
"AHU-S" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  4" )
   ..
"RSCHED" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  5" )
   ..


$ ---------------------------------------------------------
$              Polygons
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Wall Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fixed and Building Shades
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Misc Cost Related Objects
$ ---------------------------------------------------------





$ *********************************************************
$ **                                                     **
$ **      Floors / Spaces / Walls / Windows / Doors      **
$ **                                                     **
$ *********************************************************

SET-DEFAULT FOR FLOOR           
   SHAPE            = NO-SHAPE
   FLOOR-HEIGHT     = {no_def}
   ..

SET-DEFAULT FOR SPACE           
   SHAPE            = NO-SHAPE
   ..

"DEFAULT-FLOOR" = FLOOR           
   C-DIAGRAM-DATA   = *Detailed UI DiagData*
   ..
"COND-SPACE" = SPACE           
   X                = 0
   Y                = 0
   Z                = 0
   AZIMUTH          = 0
   AREA             = 516.67
   VOLUME           = 4576.78
   FLOOR-WEIGHT     = 0.1
   ZONE-TYPE        = CONDITIONED
   TEMPERATURE      = ( 68 )
   LIGHTING-SCHEDUL = ( "LIGHT-SCH" )
   INF-METHOD       = AIR-CHANGE
   INF-FLOW/AREA    = 0.682
   LIGHTING-KW      = ( 0 )
   LIGHT-TO-SPACE   = ( 1 )
   ..
"WALL-NORTH" = EXTERIOR-WALL   
   CONSTRUCTION     = "HOUSEWALL"
   OUTSIDE-EMISS    = 0.001
   INSIDE-SOL-ABS   = 0.01
   X                = 0
   Y                = 0
   Z                = 0
   HEIGHT           = 8.858
   WIDTH            = 26.248
   AZIMUTH          = 0
   TILT             = 90
   ..
"WALL-EAST" = EXTERIOR-WALL   
   CONSTRUCTION     = "HOUSEWALL"
   OUTSIDE-EMISS    = 0.001
   INSIDE-SOL-ABS   = 0.01
   X                = 26.248
   Y                = 0
   Z                = 0
   HEIGHT           = 8.858
   WIDTH            = 19.68
   AZIMUTH          = 90
   TILT             = 90
   ..
"WALL-SOUTH" = EXTERIOR-WALL   
   CONSTRUCTION     = "HOUSEWALL"
   OUTSIDE-EMISS    = 0.001
   INSIDE-SOL-ABS   = 0.01
   X                = 26.248
   Y                = 19.68
   Z                = 0
   HEIGHT           = 8.858
   WIDTH            = 26.248
   AZIMUTH          = 180
   TILT             = 90
   ..
"WALL-WEST" = EXTERIOR-WALL   
   CONSTRUCTION     = "HOUSEWALL"
   OUTSIDE-EMISS    = 0.001
   INSIDE-SOL-ABS   = 0.01
   X                = 0
   Y                = 19.68
   Z                = 0
   HEIGHT           = 8.858
   WIDTH            = 19.68
   AZIMUTH          = 270
   TILT             = 90
   ..
"FLOOR1" = EXTERIOR-WALL   
   CONSTRUCTION     = "HOUSEFLOOR"
   OUTSIDE-EMISS    = 0.001
   INSIDE-SOL-ABS   = 0.01
   X                = 0
   Y                = 19.68
   Z                = 0
   HEIGHT           = 19.68
   WIDTH            = 26.248
   AZIMUTH          = 0
   TILT             = 180
   ..
"ROOF1" = EXTERIOR-WALL   
   CONSTRUCTION     = "HOUSEROOF"
   OUTSIDE-EMISS    = 0.001
   INSIDE-SOL-ABS   = 0.01
   X                = 0
   Y                = 0
   Z                = 8.858
   HEIGHT           = 19.68
   WIDTH            = 26.248
   AZIMUTH          = 90
   TILT             = 0
   ..


$ *********************************************************
$ **                                                     **
$ **                Performance Curves                   **
$ **                                                     **
$ *********************************************************

"F-HIR-FPLR" = CURVE-FIT       
   TYPE             = QUADRATIC
   INPUT-TYPE       = COEFFICIENTS
   COEFFICIENTS     = ( -0.0005, 0.9809, 0.0281 )
   ..

$ *********************************************************
$ **                                                     **
$ **              Electric & Fuel Meters                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Electric Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fuel Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Master Meters
$ ---------------------------------------------------------

MASTER-METERS   
   MSTR-ELEC-METER  = "EM1"
   MSTR-FUEL-METER  = "FM1"
   ..


$ *********************************************************
$ **                                                     **
$ **      HVAC Circulation Loops / Plant Equipment       **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Pumps
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Circulation Loops
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chillers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Boilers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Domestic Water Heaters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Rejection
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Tower Free Cooling
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Photovoltaic Modules
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Electric Generators
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Thermal Storage
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Ground Loop Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Compliance DHW (residential dwelling units)
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **            Steam & Chilled Water Meters             **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Steam Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chilled Water Meters
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **               HVAC Systems / Zones                  **
$ **                                                     **
$ *********************************************************

"SYSTEM-1" = SYSTEM          
   TYPE             = PSZ
   HEAT-SOURCE      = FURNACE
   MAX-SUPPLY-T     = 110
   MIN-SUPPLY-T     = 55
   SUPPLY-FLOW      = 752
   FAN-SCHEDULE     = "AHU-S"
   FAN-CONTROL      = CONSTANT-VOLUME
   SUPPLY-DELTA-T   = 0.84
   SUPPLY-KW/FLOW   = 0.000266
   MOTOR-PLACEMENT  = IN-AIRFLOW
   FAN-PLACEMENT    = DRAW-THROUGH
   INDOOR-FAN-MODE  = INTERMITTENT
   COOLING-CAPACITY = 0
   COOL-SH-CAP      = 0
   CRANKCASE-HEAT   = 0
   HEATING-CAPACITY = -34120
   FURNACE-AUX      = 0
   FURNACE-HIR      = 1.25
   FURNACE-HIR-FPLR = "F-HIR-FPLR"
   FURNACE-AUX-KW   = 0
   CONTROL-ZONE     = "COND-ZONE"
   ..
"COND-ZONE" = ZONE            
   TYPE             = CONDITIONED
   DESIGN-HEAT-T    = 68
   HEAT-TEMP-SCH    = "HEATING-SCH"
   DESIGN-COOL-T    = 99
   COOL-TEMP-SCH    = "COOLING-SCH"
   THERMOSTAT-TYPE  = TWO-POSITION
   THROTTLING-RANGE = 0.1
   SPACE            = "COND-SPACE"
   ..


$ *********************************************************
$ **                                                     **
$ **                Metering & Misc HVAC                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Equipment Controls
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Load Management
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                    Utility Rates                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Ratchets
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Block Charges
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Utility Rates
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                 Output Reporting                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Loads Non-Hourly Reporting
$ ---------------------------------------------------------

LOADS-REPORT    
   SUMMARY          = ( ALL-SUMMARY )
   ..


$ ---------------------------------------------------------
$              Systems Non-Hourly Reporting
$ ---------------------------------------------------------

SYSTEMS-REPORT  
   SUMMARY          = ( ALL-SUMMARY )
   ..


$ ---------------------------------------------------------
$              Plant Non-Hourly Reporting
$ ---------------------------------------------------------

PLANT-REPORT    
   SUMMARY          = ( ALL-SUMMARY )
   ..


$ ---------------------------------------------------------
$              Economics Non-Hourly Reporting
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Hourly Reporting
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              THE END
$ ---------------------------------------------------------

END ..
COMPUTE ..
STOP ..
